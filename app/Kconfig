## app/Kconfig
```kconfig
config ZMK_BEHAVIOR_OS_LAYER
    bool "Per-profile OS layer switching for moNa2"
    depends on ZMK_SPLIT_ROLE_CENTRAL
    default n
```
